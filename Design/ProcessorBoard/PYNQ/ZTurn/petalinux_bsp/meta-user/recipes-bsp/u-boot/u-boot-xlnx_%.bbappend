SRC_URI += " file://zynq_ztrun_defconfig"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
